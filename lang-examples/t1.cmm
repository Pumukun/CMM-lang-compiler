a = 5;
b = 8;
a = b + 8;
print a;
